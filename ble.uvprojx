# Keil uVision project ble.uvprojx, settings and files
target ble (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: nRF51822_xxAC Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.14.1
  cpu: IRAM(0x20000000,0x8000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: ble +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: BLE_STACK_SUPPORT_REQD BSP_DEFINES_ONLY BOARD_PCA20006 S110 NRF51 SOFTDEVICE_PRESENT
  c misc: --c99
  c include: components\toolchain;components\toolchain\gcc;components\softdevice\s110\headers;components\drivers_nrf\hal;components\libraries\uart;components\libraries\util;components\drivers_nrf\uart;components\libraries\fifo;components\drivers_nrf\common;.\components\drivers_nrf\clock;components\softdevice\common\softdevice_handler;components\ble\common;common\softdevice_handler;.\lib;components\ble\ble_advertising
  memory RVCT4: ROM 0x18000 size 0x40000
  memory RVCT9: RAM 0x20002000 size 0x8000
  group app
    ./: main.c
  group nrf_lib
    ./components/libraries/util/: app_error.c
  group lib
    ./lib/: uart.c
  group nrf_ble
    ./components/ble/common/: ble_advdata.c
software components: CMSIS:CORE 5.0.2, Device:Startup 8.14.1, Device:StartupConfig 8.14.1
